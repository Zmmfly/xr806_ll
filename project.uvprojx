# Keil uVision project project.uvprojx, settings and files
target Firmware (6210000::V6.21::ARMCLANG)
  device: ARMCM33 ARM
  pack: ARM.Cortex_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: xr806
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Driver\CMSIS\Core\Include;C:\Keil_v5\ARM\ARMCLANG\include;.\Driver\xr806_driver_ll\inc
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x200000 size 0x48000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group Driver/xr806_driver_ll
    ./Driver/xr806_driver_ll/src/: startup_xr806.c
  group Application
    ./src/: main.c
